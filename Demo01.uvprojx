# Keil uVision project Demo01.uvprojx, settings and files
target Demo01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB
  c include: .\HW\Inc;.\CMSIS\Include;.\LIB\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HW
    ../stm32f103/HW/Src/: stm32f1xx_it.c
    ./HW/Src/: rcc.c led.c sw.c
  group LIB
    ../stm32f103/LIB/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c
    ./LIB/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c
  group CMSIS
    ../stm32f103/CMSIS/Source/: system_stm32f1xx.c startup_stm32f103xb.s
